# Keil uVision project alarm.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: alarm +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\System;.\Hardware\LED;.\Hardware\BEEP;.\Hardware\LCD;.\Hardware\RTC;.\Hardware\KEY;.\Hardware\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ./main/: startup_stm32f10x_hd.s main.c
  group System
    ./System/: delay.c define.c
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/BEEP/: beep.c
    ./Hardware/LCD/: lcd.c touch.c
    ./Hardware/RTC/: rtc.c
    ./Hardware/KEY/: key.c
    ./Hardware/USART/: usart.c
